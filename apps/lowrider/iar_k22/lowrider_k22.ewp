# IAR project lowrider_k22.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MK22FN512VLH12; DEBUG; CLOCK_SETUP=1; ARM_MATH_CM4; __FPU_PRESENT=1; AR_ENABLE_TICKLESS_IDLE=0
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: ..\src; ..\..\..\src\devices\MK22F51212; ..\..\..\src\ksdk; ..\..\..\src\CMSIS\Include; ..\..\..\src\argon\cortex_m; ..\..\..\src\argon; ..\..\..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: CPU_MK22FN512VLH12
  ILINK.IlinkOutputFile: lowrider_k22.out
  ILINK.IlinkConfigDefines: __heap_size__=8192; __stack_size__=4096
  ILINK.IlinkIcfFile: ..\..\..\src\devices\MK22F51212\iar\MK22FN512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group argon
    ../../../src/argon/cortex_m/: ar_asm_macros.h ar_atomics.h ar_atomics_cm4.S ar_handlers_cm4.S ar_main_thread.cpp ar_port.cpp ar_port.h
    ../../../src/argon/src/: ar_channel.cpp ar_config.h ar_internal.h ar_kernel.cpp ar_mutex.cpp ar_queue.cpp ar_runloop.cpp ar_sem.cpp ar_thread.cpp ar_timer.cpp
    ../../../src/argon/: ar_classes.h ar_kernel.h argon.h
  group dsp
    ../../../src/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
    ../../../src/CMSIS/DSP_Lib/Source/SupportFunctions/: arm_float_to_q15.c
    ../../../src/CMSIS/DSP_Lib/Source/BasicMathFunctions/: arm_mult_f32.c arm_scale_f32.c
    ../../../src/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_sin_f32.c arm_sin_q15.c
  group ksdk
    ../../../src/ksdk/: fsl_common.c fsl_common.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_fxos.c fsl_fxos.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_port.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_sgtl5000.c fsl_sgtl5000.h fsl_sim.c fsl_sim.h fsl_uart.c fsl_uart.h
  group src
    ../src/: ar_config.h ar_envelope.cpp ar_envelope.h audio_filter.h audio_output.cpp audio_output.h audio_output_converter.cpp audio_output_converter.h audio_ramp.cpp audio_ramp.h main.cpp sequencer.cpp sequencer.h
  group startup
    ../../../src/devices/MK22F51212/: fsl_clock.c fsl_clock.h system_MK22F51212.c system_MK22F51212.h
    ../../../src/devices/MK22F51212/iar/: startup_MK22F51212.s
